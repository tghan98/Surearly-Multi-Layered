# IAR project MFx_Layered.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151F3 STM8L151F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_LD
  ICCSTM8.CCIncludePath2: ../Drivers/STM8L15x_StdPeriph_Driver/inc; ../Inc; ../User; ../User/01_HW_Drive; ../User/02_Module; ../User/03_App
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: OVULATION_MULTI_New.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group Src
    ../Src/: main.c stm8l15x_it.c
  group Drivers
    ../Drivers/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../User/: System_Main.c
  group User/01_HW_Drive
    ../User/01_HW_Drive/: HW_Tick_Drive.c HW_CLK_Drive.c HW_GPIO_Drive.c HW_ADC_Drive.c HW_UART_Drive.c HW_EEPROM_Drive.c HW_PWR_Drive.c
  group User/02_Module
    ../User/02_Module/: Optic.c Lcd.c Eeprom.c PcComm.c
  group User/03_App/2_Exec
    ../User/03_App/: APP_EXEC_Measure.c APP_EXEC_Measure.h
  group User/03_App/3_Data
    ../User/03_App/: APP_DATA_Record.c APP_DATA_Config.h APP_DATA_ErrorCode.h APP_DATA_Record.h
